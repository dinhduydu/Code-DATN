<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CAN_F1_HCSR04_15_11_22.ewp</path>
  </project>
  <batchBuild />
</workspace>
