<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CAN_Node2_SDS011_Ze08_Mq135.ewp</path>
    </project>
    <batchBuild />
</workspace>
